# Keil uVision project STM32_CGMCU.uvprojx, settings and files
target DHT11 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32_CGMCU
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\HARDWARE;..\HARDWARE\DHT11;..\HARDWARE\LED;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\SYSTEM\adcx;..\HARDWARE\OLED;..\HARDWARE\BUMP;..\HARDWARE\KEY;..\HARDWARE\WATER
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: stm32f10x_it.c system_stm32f10x.c main.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/BUMP/: bump.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/WATER/: water.c water.h
    ../HARDWARE/: rain.c rain.h Buzzer.c Buzzer.h
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/adcx/: adcx.c adcx.h
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_adc.c stm32f10x_tim.c
